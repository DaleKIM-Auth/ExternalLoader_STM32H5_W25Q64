# IAR project W25Q64JV_STM32H562.ewp, settings and files
configuration W25Q64JV_STM32H562 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H562RG ST STM32H562RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 0
  ICCARM.CCDefines: STM32H562xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Includes\CMSIS; ..\Includes\Library; ..\Includes\Loader
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: W25Q64JV_STM32H562.srec
  ILINK.IlinkOutputFile: W25Q128JV_STM32H562_Nucleo.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Library
    ../Source/Library/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_xspi.c system_stm32h5xx.c w25q64jv_driver.c
  group Loader
    ../Source/Loader/: Dev_Inf.c Loader_Src.c
